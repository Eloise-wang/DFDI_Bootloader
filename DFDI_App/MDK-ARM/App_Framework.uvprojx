# Keil uVision project App_Framework.uvprojx, settings and files
target App_Framework (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AC78406HGLA AutoChips
  pack: AutoChips.AC7840x_DFP.3.2.0
  cpu: IRAM(0x1FFF0000,0x00010000) IRAM2(0x20000000,0x0000F000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App_Framework.axf +hex
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AC7840X_SERIES
  c include: ..\Inc\Common_Cfg;..\Inc\App;..\Src\App;..\CMSIS\Driver\inc;..\CMSIS\Device;..\CMSIS\Rtos\osif
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0xf000
  group Application/User
    ../Src/App/: main.c
software components: CMSIS:CORE 5.0.1, Board Support:AC7840x Development Kit:Debug 1.0.0, Device:ATC Drivers:ACMP 1.0.0, Device:ATC Drivers:ADC 1.0.0, Device:ATC Drivers:CAN 1.0.1, Device:ATC Drivers:CKGEN 3.0.1, Device:ATC Drivers:CTU 1.0.0, Device:ATC Drivers:DMA 1.0.0, Device:ATC Drivers:EFLASH 1.0.1, Device:ATC Drivers:EIM 1.0.0, Device:ATC Drivers:GPIO 1.0.0, Device:ATC Drivers:PCT 1.0.0, Device:ATC Drivers:PDT 1.0.0, Device:ATC Drivers:PWM 1.0.1, Device:ATC Drivers:RCM 1.0.0, Device:ATC Drivers:RTC 3.0.1, Device:ATC Drivers:SPI 3.2.0, Device:ATC Drivers:SPM 1.0.0, Device:ATC Drivers:TIMER 1.0.0, Device:ATC Drivers:UART 1.0.1, Device:ATC Drivers:WDG 1.0.0, Device:ATC OSIF:OSIF 1.0.0, Device:Startup 3.0.0
